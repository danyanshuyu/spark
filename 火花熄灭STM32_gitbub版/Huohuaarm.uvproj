# Keil uVision project Huohuaarm.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Huohuaarm +hex
  c flags: Optim=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FWlib
    ./FWlib/: STM32F10xR.LIB
  group Startup
    ./Startup/: cortexm3_macro.s stm32f10x_vector.s
  group User
    ./User/: main.c Functions.c stm32f10x_it.c fsmc_cpld_sram.c PCF8563_I2c.c 24C08_I2c.c Flash_operation.c Rtc_operation.c Spark_test.c Fault_test.c Disable_test .c Params.c language.c Screen.c
